<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>merapi_decode</value></param>
<param><key>author</key><value>Handiko Gesang - Unit Rumah Produksi - PT. Datto Asia Teknologi</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Merapi Decode - PT. Datto Asia Teknologi</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>device</value></param>
<param><key>value</key><value>['rtl=0','file='+str(path),'rate=300e3','repeat=true','throttle=true']</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>device_bank</value></param>
<param><key>value</key><value>['rtl=0',str(device[1]) + ',' + str(device[2]) + ',' + str(device[3]) + ',' + str(device[4])]</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>433.25</value></param>
<param><key>gui_hint</key><value>tab@0:2,0,1,1</value></param>
<param><key>label</key><value>Freq (MHz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rate_bank</value></param>
<param><key>value</key><value>[2.4e6,300e3]</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rfgain</value></param>
<param><key>value</key><value>30</value></param>
<param><key>gui_hint</key><value>tab@0:2,1,1,1</value></param>
<param><key>label</key><value>RF Gain (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>1.0</value></param>
<param><key>stop</key><value>49.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>rate_bank[source]</value></param>
</block>
<block>
<key>Merapi_iot_pub</key>
<param><key>id</key><value>Merapi_iot_pub_0</value></param>
<param><key>api_key</key><value></value></param>
<param><key>accept_type</key><value>"*/*"</value></param>
<param><key>content_type</key><value>"application/x-www-form-urlencoded"</value></param>
<param><key>field1</key><value>""</value></param>
<param><key>field2</key><value>""</value></param>
<param><key>field3</key><value>""</value></param>
<param><key>field4</key><value>""</value></param>
<param><key>field5</key><value>""</value></param>
<param><key>field6</key><value>""</value></param>
<param><key>field7</key><value>""</value></param>
<param><key>field8</key><value>""</value></param>
<param><key>address</key><value>"api.thingspeak.com"</value></param>
</block>
<block>
<key>Merapi_merapi_rx</key>
<param><key>id</key><value>Merapi_merapi_rx_0</value></param>
<param><key>fsk_hi_tone</key><value>2200.0</value></param>
<param><key>fsk_lo_tone</key><value>1200.0</value></param>
<param><key>baud</key><value>1200</value></param>
<param><key>bpf_trans</key><value>1e3</value></param>
<param><key>filter_len</key><value>400</value></param>
<param><key>gain</key><value>10e3</value></param>
<param><key>hi</key><value>0.7</value></param>
<param><key>low</key><value>0.5</value></param>
<param><key>input_rate</key><value>300e3</value></param>
<param><key>gmu</key><value>0.5</value></param>
<param><key>mu</key><value>0.5</value></param>
</block>
<block>
<key>Merapi_parse_frame</key>
<param><key>id</key><value>Merapi_parse_frame_0</value></param>
<param><key>filename</key><value>merapi_log.csv</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>localhost</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>corr0</key><value>55</value></param>
<param><key>freq0</key><value>freq*1e6</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>rfgain</value></param>
<param><key>args</key><value>device_bank[source]</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>rate_bank[source]</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>path</value></param>
<param><key>label</key><value>IQ File Recording Path</value></param>
<param><key>value</key><value>"gqrx_20180404_011711_144119900_300000_fc.raw"</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>300e3</value></param>
<param><key>fc</key><value>freq*1e6</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>gui_hint</key><value>tab@0:0,0,1,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>RF Spectrum</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-100</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>tab@1:0,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>AFSK Waveform</value></param>
<param><key>size</key><value>8192*8</value></param>
<param><key>srate</key><value>48e3</value></param>
<param><key>tr_delay</key><value>0.15</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>burst_start</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>tab@1:1,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>width1</key><value>2</value></param>
<param><key>name</key><value>Softbits</value></param>
<param><key>srate</key><value>2400</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>burst_start</value></param>
<param><key>type</key><value>msg_float</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>ymax</key><value>3</value></param>
<param><key>ymin</key><value>-3</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>300e3</value></param>
<param><key>fc</key><value>freq*1e6</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>gui_hint</key><value>tab@0:1,0,1,2</value></param>
<param><key>int_max</key><value>-20</value></param>
<param><key>int_min</key><value>-120</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>6</value></param>
<param><key>name</key><value>RF Spectrogram</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>int(samp_rate)</value></param>
<param><key>interp</key><value>int(300e3)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>source</value></param>
<param><key>label</key><value>Input Source: 0 = SDR, 1 = IQ File</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>gui_hint</key><value>0,0,1,2</value></param>
<param><key>label0</key><value>RF Input</value></param>
<param><key>label1</key><value>Demodulation</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<connection><source_block_id>Merapi_merapi_rx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Merapi_merapi_rx_0</source_block_id><sink_block_id>Merapi_parse_frame_0</sink_block_id><source_key>frame_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>Merapi_merapi_rx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>softbits</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>Merapi_merapi_rx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Merapi_merapi_rx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Merapi_parse_frame_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>info_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>Merapi_parse_frame_0</source_block_id><sink_block_id>Merapi_iot_pub_0</sink_block_id><source_key>parse_out</source_key><sink_key>parse_in</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>Merapi_merapi_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
